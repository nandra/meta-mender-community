require u-boot-radxa.inc

SRC_URI:append = " \
        file://0002-Do-not-update-serial.patch \
"

